# Keil uVision project Welding_adapter.uvprojx, settings and files
target Welding_adapter (ARM-ADS)
  device: STM32F373VC STMicroelectronics
  pack: Keil.STM32F3xx_DFP.2.0.0
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0x8000000-0x803FFFF) CLOCK(72000000) FPU2 CPUTYPE("Cortex-M4")
  output: Welding_adapter
  c flags: Optim=2 OneElfS=1 uC99=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F373xC, ARM_MATH_CM4, __FPU_PRESENT = 1U, __USE_CMSIS
  c misc: --C99
  c include: ../Inc; ../Drivers/STM32F3xx_HAL_Driver/Inc; ../Drivers/STM32F3xx_HAL_Driver/Inc/Legacy; ../Middlewares/ST/STM32_USB_Device_Library/Core/Inc; ../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Inc; ../Drivers/CMSIS/Device/ST/STM32F3xx/Include; ../Drivers/CMSIS/Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  link misc: --diag_suppress=L6329
  group Application/User
    ../Src/: stm32f3xx_it.c main.c test.c cord.c machines.c com_meas_tasks.c
    ./: do_task.c
    ../Inc/: com_meas_tasks.h
  group Middlewares/USB_Device_Library
    ../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_ioreq.c usbd_ctlreq.c usbd_core.c
    ../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
  group Drivers/STM32F3xx_HAL_Driver
    ../Drivers/STM32F3xx_HAL_Driver/Src/: stm32f3xx_hal_dma.c stm32f3xx_hal_gpio.c stm32f3xx_hal_pcd_ex.c stm32f3xx_hal.c stm32f3xx_hal_spi.c stm32f3xx_hal_pcd.c stm32f3xx_hal_pwr.c stm32f3xx_hal_rcc.c stm32f3xx_hal_tim_ex.c stm32f3xx_hal_pwr_ex.c stm32f3xx_hal_flash_ex.c stm32f3xx_hal_uart.c stm32f3xx_hal_rcc_ex.c stm32f3xx_hal_cortex.c stm32f3xx_hal_tim.c stm32f3xx_hal_flash.c stm32f3xx_hal_spi_ex.c stm32f3xx_hal_i2c_ex.c stm32f3xx_hal_sdadc.c stm32f3xx_hal_uart_ex.c stm32f3xx_hal_i2c.c
  group Drivers/CMSIS
    ../Src/: system_stm32f3xx.c
    ../DSP_Lib/Source/FilteringFunctions/: arm_biquad_cascade_df1_f32.c arm_correlate_f32.c
    ../DSP_Lib/Source/BasicMathFunctions/: arm_mult_f32.c
    ../DSP_Lib/Source/FastMathFunctions/: arm_cos_f32.c arm_sin_f32.c
    ../DSP_Lib/Source/CommonTables/: arm_common_tables.c arm_const_structs.c
    ../DSP_Lib/Source/TransformFunctions/: arm_cfft_radix4_f32.c arm_cfft_radix4_init_f32.c arm_bitreversal.c arm_cfft_f32.c arm_cfft_radix8_f32.c arm_cfft_radix2_f32.c arm_cfft_radix2_init_f32.c arm_rfft_f32.c arm_rfft_fast_f32.c arm_rfft_fast_init_f32.c
    ../DSP_Lib/Source/ComplexMathFunctions/: arm_cmplx_mag_f32.c
    ../DSP_Lib/Source/StatisticsFunctions/: arm_mean_f32.c
    ../DSP_Lib/Source/SupportFunctions/: arm_copy_f32.c
  group Application/MDK-ARM
    ./: startup_stm32f373xc.s
  group OS
    ../Src/: os.c
  group Drivers/Configurations
    ../Src/: usbd_cdc_if.c usbd_conf.c stm32f3xx_hal_msp.c usb_device.c usbd_desc.c clock.c comunication.c gpio.c sdadc.c timer.c
    ./: rel_driver.c usb.c serial_com.c
software components: CMSIS:CORE 4.1.0
